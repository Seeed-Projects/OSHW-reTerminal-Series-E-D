// Implementation notes (mirrors online_img2bitmap_.html):
//   - Luminance:        Y = 0.2126*R + 0.7152*G + 0.0722*B  (BT.709)
//   - Gamma:            x' = pow(x/255, 1/g) * 255
//   - BW threshold:     <128 -> black, >=128 -> white (same for ordered with Bayer*4+0.5)
//   - Error kernels:    integer numerator / denominator pairs identical to the JS code
//   - Palette mapping:  weighted RGB distance (squared) like nearestColor() in the HTML
//
// The function works on RGB888 / Gray rather than the HTML's RGBA because we don't have
// alpha channel for SD card photos. If a future use-case needs alpha-composite (icon
// mode), see compositeTransparentForBW() in the HTML for the math.
#include "dither.h"

#include <cmath>
#include <cstring>

namespace {

// ----- Palettes -----------------------------------------------------------------------

struct Rgb { uint8_t r, g, b; };

// Gray16: 0..15, step 17.
static Rgb make_gray(uint8_t v) { return {v, v, v}; }

// E6 mapping (white, green, red, yellow, blue, black) and the raw e-paper codes used
// by the HTML tool and the EPaper firmware.
static const Rgb kE6Rgb[6] = {
    {255, 255, 255},  // 0: WHITE  (code 0x0)
    { 29, 185,  84},  // 1: GREEN  (code 0x2)
    {229,  57,  53},  // 2: RED    (code 0x6)
    {255, 216,   0},  // 3: YELLOW (code 0xB)
    {  0,  76, 255},  // 4: BLUE   (code 0xD)
    {  0,   0,   0},  // 5: BLACK  (code 0xF)
};
static const uint8_t kE6Code[6] = {0x0, 0x2, 0x6, 0xB, 0xD, 0xF};

// ----- Bayer 8x8 ---------------------------------------------------------------------

static const uint8_t kBayer8[64] = {
     0, 48, 12, 60,  3, 51, 15, 63,
    32, 16, 44, 28, 35, 19, 47, 31,
     8, 56,  4, 52, 11, 59,  7, 55,
    40, 24, 36, 20, 43, 27, 39, 23,
     2, 50, 14, 62,  1, 49, 13, 61,
    34, 18, 46, 30, 33, 17, 45, 29,
    10, 58,  6, 54,  9, 57,  5, 53,
    42, 26, 38, 22, 41, 25, 37, 21,
};


// Blue-noise threshold matrix, 32x32, generated by void-and-cluster
// (Ulichney) on a torus with sigma=1.5. Replaces the regular Bayer grid
// with an aperiodic dot pattern -- no cross-hatch on gradients.
static const uint8_t kBlueNoise32[1024] = {
    28, 154, 73, 132, 150, 212, 80, 38, 195, 58, 247, 10, 197, 217, 29, 253,
    139, 203, 10, 246, 142, 225, 87, 202, 56, 101, 243, 75, 160, 4, 208, 89,
    119, 216, 105, 36, 231, 1, 186, 161, 20, 133, 175, 106, 69, 163, 90, 57,
    160, 38, 86, 213, 21, 164, 40, 118, 228, 156, 36, 125, 219, 58, 138, 169,
    11, 57, 246, 172, 95, 67, 127, 99, 232, 79, 211, 45, 225, 140, 0, 207,
    105, 230, 183, 114, 61, 192, 254, 70, 180, 8, 206, 88, 183, 103, 40, 228,
    181, 200, 124, 18, 194, 153, 248, 44, 204, 5, 151, 122, 22, 242, 178, 126,
    23, 70, 149, 45, 132, 92, 12, 146, 96, 137, 51, 249, 21, 143, 241, 79,
    101, 147, 43, 83, 227, 53, 26, 179, 118, 57, 255, 191, 76, 97, 53, 218,
    169, 250, 11, 203, 234, 157, 215, 35, 233, 197, 116, 167, 70, 201, 162, 26,
    222, 69, 241, 162, 130, 104, 220, 142, 83, 170, 102, 37, 160, 198, 115, 32,
    79, 129, 98, 172, 27, 76, 110, 187, 64, 21, 81, 225, 0, 117, 53, 129,
    9, 206, 32, 188, 4, 201, 71, 15, 198, 236, 18, 134, 221, 7, 233, 152,
    186, 48, 226, 63, 120, 244, 49, 167, 130, 246, 147, 42, 211, 88, 254, 172,
    85, 140, 116, 93, 59, 151, 245, 123, 43, 153, 65, 179, 48, 121, 67, 89,
    244, 3, 210, 144, 190, 13, 208, 95, 5, 177, 100, 185, 128, 155, 36, 193,
    236, 45, 177, 251, 217, 24, 169, 89, 224, 107, 213, 81, 242, 155, 205, 26,
    136, 163, 110, 35, 87, 161, 124, 229, 72, 217, 28, 59, 238, 12, 105, 62,
    153, 214, 19, 73, 135, 106, 51, 184, 1, 131, 24, 199, 103, 13, 174, 98,
    216, 55, 76, 197, 252, 60, 31, 145, 46, 159, 119, 200, 78, 166, 226, 124,
    2, 98, 121, 168, 39, 208, 238, 75, 155, 251, 166, 41, 129, 59, 253, 38,
    123, 181, 236, 23, 131, 178, 104, 241, 190, 90, 249, 17, 141, 208, 31, 183,
    248, 56, 202, 232, 148, 8, 118, 193, 33, 63, 93, 188, 233, 146, 194, 78,
    224, 11, 145, 91, 219, 4, 205, 78, 12, 135, 41, 173, 108, 48, 93, 72,
    170, 140, 22, 86, 65, 176, 95, 141, 213, 112, 222, 18, 76, 113, 2, 160,
    102, 50, 173, 116, 68, 151, 43, 168, 115, 232, 195, 67, 216, 240, 136, 199,
    40, 220, 107, 190, 254, 32, 227, 52, 13, 179, 150, 46, 174, 214, 34, 239,
    129, 205, 245, 30, 193, 234, 125, 224, 60, 29, 150, 84, 7, 161, 21, 112,
    82, 6, 165, 47, 121, 154, 201, 72, 243, 84, 127, 249, 101, 139, 54, 177,
    66, 17, 82, 158, 52, 97, 20, 82, 211, 177, 106, 252, 122, 188, 64, 232,
    126, 247, 143, 213, 77, 23, 108, 133, 164, 34, 202, 8, 69, 191, 222, 92,
    145, 188, 111, 210, 137, 255, 184, 159, 138, 14, 52, 200, 36, 97, 150, 203,
    176, 62, 94, 16, 170, 240, 186, 4, 223, 104, 56, 230, 157, 24, 120, 6,
    250, 42, 227, 25, 74, 1, 112, 37, 242, 77, 220, 134, 168, 223, 19, 49,
    104, 30, 191, 229, 132, 41, 92, 63, 196, 144, 181, 122, 95, 242, 73, 209,
    163, 132, 99, 176, 148, 219, 198, 62, 100, 187, 113, 3, 61, 81, 244, 139,
    212, 239, 152, 53, 109, 215, 158, 250, 32, 80, 15, 215, 42, 175, 148, 50,
    87, 16, 64, 239, 49, 90, 128, 229, 151, 27, 164, 247, 205, 119, 183, 8,
    67, 120, 86, 0, 184, 72, 15, 138, 113, 226, 163, 65, 196, 29, 108, 189,
    230, 171, 207, 115, 192, 30, 168, 9, 54, 235, 90, 43, 146, 28, 98, 157,
    196, 37, 173, 209, 128, 238, 100, 204, 174, 48, 94, 255, 136, 85, 237, 22,
    121, 39, 141, 12, 158, 245, 80, 212, 117, 195, 138, 71, 193, 231, 54, 221,
    17, 139, 254, 58, 22, 166, 34, 60, 235, 3, 152, 118, 13, 210, 143, 69,
    217, 93, 251, 75, 105, 44, 134, 180, 68, 18, 221, 109, 10, 161, 127, 80,
    181, 109, 91, 148, 221, 111, 189, 87, 127, 192, 219, 39, 173, 55, 184, 1,
    156, 197, 54, 176, 231, 194, 20, 100, 248, 165, 38, 182, 252, 94, 33, 240,
    50, 228, 9, 201, 77, 47, 249, 142, 25, 66, 106, 79, 245, 124, 91, 241,
    114, 29, 130, 6, 146, 66, 215, 154, 51, 125, 85, 149, 56, 207, 172, 144,
    209, 70, 162, 35, 126, 155, 7, 211, 169, 239, 156, 200, 25, 216, 164, 44,
    206, 84, 185, 225, 111, 33, 86, 227, 0, 191, 237, 23, 131, 73, 5, 99,
    26, 186, 113, 247, 179, 226, 99, 74, 117, 46, 10, 135, 62, 109, 11, 71,
    137, 235, 61, 96, 167, 203, 142, 116, 170, 71, 204, 111, 223, 187, 246, 122,
    231, 135, 52, 91, 16, 61, 198, 30, 182, 214, 96, 178, 233, 152, 189, 250,
    171, 16, 153, 41, 253, 19, 55, 243, 31, 103, 46, 159, 17, 89, 42, 156,
    85, 2, 194, 218, 149, 110, 134, 243, 147, 57, 253, 31, 83, 45, 126, 88,
    35, 112, 218, 190, 74, 128, 182, 83, 210, 136, 235, 65, 178, 140, 218, 58,
    175, 244, 68, 166, 27, 234, 44, 88, 3, 125, 159, 107, 196, 222, 20, 202,
    228, 59, 133, 2, 108, 162, 223, 14, 154, 185, 5, 96, 255, 27, 114, 204,
    102, 143, 34, 123, 82, 206, 158, 187, 229, 75, 207, 14, 137, 60, 165, 102,
    147, 182, 84, 209, 237, 33, 97, 63, 115, 40, 224, 120, 199, 77, 165, 14,
    47, 212, 94, 238, 174, 15, 64, 103, 25, 171, 49, 237, 180, 78, 234, 7,
    47, 240, 28, 157, 50, 195, 145, 248, 214, 81, 167, 55, 144, 39, 230, 131,
    251, 180, 9, 199, 51, 114, 252, 141, 220, 119, 92, 149, 37, 110, 130, 189,
    74, 117, 175, 101, 68, 123, 6, 171, 24, 133, 192, 19, 236, 107, 185, 66,
};

// ----- Error diffusion kernels -------------------------------------------------------

struct KernelTap { int dx, dy, num, den; };

static const KernelTap kFS[] = {
    { 1, 0, 7, 16},
    {-1, 1, 3, 16},
    { 0, 1, 5, 16},
    { 1, 1, 1, 16},
};
static const KernelTap kJarvis[] = {
    { 1, 0, 7, 48}, { 2, 0, 5, 48},
    {-2, 1, 3, 48}, {-1, 1, 5, 48}, { 0, 1, 7, 48}, { 1, 1, 5, 48}, { 2, 1, 3, 48},
    {-2, 2, 1, 48}, {-1, 2, 3, 48}, { 0, 2, 5, 48}, { 1, 2, 3, 48}, { 2, 2, 1, 48},
};
static const KernelTap kAtkinson[] = {
    { 1, 0, 1, 8}, { 2, 0, 1, 8},
    {-1, 1, 1, 8}, { 0, 1, 1, 8}, { 1, 1, 1, 8},
    { 0, 2, 1, 8},
};

static const KernelTap* pick_kernel(DitherMethod m, size_t& nout) {
  switch (m) {
    case DITHER_JARVIS:   nout = sizeof(kJarvis)   / sizeof(KernelTap); return kJarvis;
    case DITHER_ATKINSON: nout = sizeof(kAtkinson) / sizeof(KernelTap); return kAtkinson;
    default:              nout = sizeof(kFS)       / sizeof(KernelTap); return kFS;
  }
}

// ----- Math helpers ------------------------------------------------------------------

static inline int clamp_u8(int v) { return v < 0 ? 0 : (v > 255 ? 255 : v); }

static inline int luma(int r, int g, int b) {
  // 0.2126 R + 0.7152 G + 0.0722 B, fixed-point with Q15 weights.
  // 0.2126 ≈ 6966 / 32768, 0.7152 ≈ 23436 / 32768, 0.0722 ≈ 2366 / 32768
  const int w = 6966 * r + 23436 * g + 2366 * b;
  return w >> 15;
}

static inline int apply_gamma(int gray, float g) {
  if (g <= 0.0f || (g > 0.999f && g < 1.001f)) return gray;
  const float x = gray / 255.0f;
  const float y = powf(x, 1.0f / g);
  return clamp_u8(static_cast<int>(y * 255.0f + 0.5f));
}

// Squared distance (no weighting) — keeps things consistent with the HTML reference.
static inline int rgb_dist2(int r, int g, int b, const Rgb& p) {
  const int dr = r - p.r, dg = g - p.g, db = b - p.b;
  return dr * dr + dg * dg + db * db;
}

static inline int nearest_e6(int r, int g, int b) {
  int best = 0;
  int bestD = rgb_dist2(r, g, b, kE6Rgb[0]);
  for (int i = 1; i < 6; ++i) {
    const int d = rgb_dist2(r, g, b, kE6Rgb[i]);
    if (d < bestD) { bestD = d; best = i; }
  }
  return best;
}

// Gray16 nearest: simply round-divide by 17.
static inline int nearest_gray16(int gray) {
  // (gray + 8) / 17 rounds to the nearest of [0,17,34,...,255]
  int q = (gray + 8) / 17;
  if (q < 0) q = 0;
  if (q > 15) q = 15;
  return q;
}

// Gray4 nearest: round to the nearest of [0, 85, 170, 255].
// (gray + 42) / 85 maps 0..42->0, 43..127->1, 128..212->2, 213..255->3.
static inline int nearest_gray4(int gray) {
  int q = (gray + 42) / 85;
  if (q < 0) q = 0;
  if (q > 3) q = 3;
  return q;
}

// ----- BW ---------------------------------------------------------------------------

static void bw_none(const uint8_t* rgb, int W, int H, float gamma, uint8_t* out) {
  for (int i = 0, p = 0; p < W * H; ++p, i += 3) {
    int g = apply_gamma(luma(rgb[i], rgb[i + 1], rgb[i + 2]), gamma);
    out[p] = (g < 128) ? 0 : 1;
  }
}

static void bw_bayer(const uint8_t* rgb, int W, int H, float gamma, uint8_t* out) {
  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int i = (y * W + x) * 3;
      const int g = apply_gamma(luma(rgb[i], rgb[i + 1], rgb[i + 2]), gamma);
      // (Bayer[y%8 * 8 + x%8] + 0.5) * 4  -> integer equivalent
      const int t = (kBayer8[(y & 7) * 8 + (x & 7)] * 4) + 2;
      out[y * W + x] = (g < t) ? 0 : 1;
    }
  }
}

// Error-diffusion BW with int16 working buffer (PSRAM). Falls back to nearest if alloc fails.
static bool bw_diffuse(const uint8_t* rgb, int W, int H, float gamma,
                       DitherMethod method, uint8_t* out) {
  const size_t n = static_cast<size_t>(W) * static_cast<size_t>(H);
  int16_t* buf = static_cast<int16_t*>(ps_malloc(n * sizeof(int16_t)));
  if (!buf) buf = static_cast<int16_t*>(malloc(n * sizeof(int16_t)));
  if (!buf) {
    Serial1.printf("[dither] WARN: error-diffusion buffer %lu kB alloc FAILED -> "
                   "falling back to DITHER_NONE (image will look the same as no dither).\n",
                   (unsigned long)(n * sizeof(int16_t) / 1024));
    bw_none(rgb, W, H, gamma, out);
    return false;
  }
  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int i = (y * W + x) * 3;
      buf[y * W + x] = static_cast<int16_t>(
          apply_gamma(luma(rgb[i], rgb[i + 1], rgb[i + 2]), gamma));
    }
  }
  size_t kn = 0;
  const KernelTap* K = pick_kernel(method, kn);
  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int idx = y * W + x;
      const int old = buf[idx];
      const int nv = (old < 128) ? 0 : 255;
      out[idx] = (nv == 0) ? 0 : 1;
      const int err = old - nv;
      for (size_t k = 0; k < kn; ++k) {
        const int nx = x + K[k].dx;
        const int ny = y + K[k].dy;
        if (nx < 0 || nx >= W || ny < 0 || ny >= H) continue;
        const int ni = ny * W + nx;
        const int v = buf[ni] + err * K[k].num / K[k].den;
        buf[ni] = static_cast<int16_t>(clamp_u8(v));
      }
    }
  }
  free(buf);
  return true;
}

// ----- Gray16 -----------------------------------------------------------------------

static void gray16_none(const uint8_t* rgb, int W, int H, float gamma, uint8_t* out) {
  for (int i = 0, p = 0; p < W * H; ++p, i += 3) {
    const int g = apply_gamma(luma(rgb[i], rgb[i + 1], rgb[i + 2]), gamma);
    out[p] = static_cast<uint8_t>(nearest_gray16(g));
  }
}

static void gray16_bayer(const uint8_t* rgb, int W, int H, float gamma, uint8_t* out) {
  // The HTML's orderedColor mixes in a `spread = 64` perturbation; for 16-level gray
  // we want the perturbation to be on the order of one level (= 17), which is roughly
  // 64/4. Use the same formula as HTML but scale the result back into the 0..255 range.
  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int i = (y * W + x) * 3;
      int g = apply_gamma(luma(rgb[i], rgb[i + 1], rgb[i + 2]), gamma);
      // mod ∈ [-32, +32], same as (bayer/64 - 0.5) * 64.
      const int mod = kBayer8[(y & 7) * 8 + (x & 7)] - 32;
      g = clamp_u8(g + mod);
      out[y * W + x] = static_cast<uint8_t>(nearest_gray16(g));
    }
  }
}

static bool gray16_diffuse(const uint8_t* rgb, int W, int H, float gamma,
                           DitherMethod method, uint8_t* out) {
  const size_t n = static_cast<size_t>(W) * static_cast<size_t>(H);
  int16_t* buf = static_cast<int16_t*>(ps_malloc(n * sizeof(int16_t)));
  if (!buf) buf = static_cast<int16_t*>(malloc(n * sizeof(int16_t)));
  if (!buf) {
    Serial1.printf("[dither] WARN: error-diffusion buffer %lu kB alloc FAILED -> "
                   "falling back to DITHER_NONE (image will look the same as no dither).\n",
                   (unsigned long)(n * sizeof(int16_t) / 1024));
    gray16_none(rgb, W, H, gamma, out);
    return false;
  }
  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int i = (y * W + x) * 3;
      buf[y * W + x] = static_cast<int16_t>(
          apply_gamma(luma(rgb[i], rgb[i + 1], rgb[i + 2]), gamma));
    }
  }
  size_t kn = 0;
  const KernelTap* K = pick_kernel(method, kn);
  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int idx = y * W + x;
      const int old = clamp_u8(buf[idx]);
      const int q = nearest_gray16(old);
      out[idx] = static_cast<uint8_t>(q);
      const int qv = q * 17;
      const int err = old - qv;
      for (size_t k = 0; k < kn; ++k) {
        const int nx = x + K[k].dx;
        const int ny = y + K[k].dy;
        if (nx < 0 || nx >= W || ny < 0 || ny >= H) continue;
        const int ni = ny * W + nx;
        const int v = buf[ni] + err * K[k].num / K[k].den;
        buf[ni] = static_cast<int16_t>(clamp_u8(v));
      }
    }
  }
  free(buf);
  return true;
}

// ----- Gray4 -------------------------------------------------------------------------

static void gray4_none(const uint8_t* rgb, int W, int H, float gamma, uint8_t* out) {
  for (int i = 0, p = 0; p < W * H; ++p, i += 3) {
    const int g = apply_gamma(luma(rgb[i], rgb[i + 1], rgb[i + 2]), gamma);
    out[p] = static_cast<uint8_t>(nearest_gray4(g));
  }
}

static void gray4_bayer(const uint8_t* rgb, int W, int H, float gamma, uint8_t* out) {
  // 4 levels span 0..255 in steps of 85, so one Bayer step (~32) is well below one level.
  // The HTML's orderedColor uses spread=64; here we scale that down to match Gray4 step.
  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int i = (y * W + x) * 3;
      int g = apply_gamma(luma(rgb[i], rgb[i + 1], rgb[i + 2]), gamma);
      const int mod = kBayer8[(y & 7) * 8 + (x & 7)] - 32;  // [-32, +31]
      g = clamp_u8(g + mod);
      out[y * W + x] = static_cast<uint8_t>(nearest_gray4(g));
    }
  }
}

static bool gray4_diffuse(const uint8_t* rgb, int W, int H, float gamma,
                          DitherMethod method, uint8_t* out) {
  const size_t n = static_cast<size_t>(W) * static_cast<size_t>(H);
  int16_t* buf = static_cast<int16_t*>(ps_malloc(n * sizeof(int16_t)));
  if (!buf) buf = static_cast<int16_t*>(malloc(n * sizeof(int16_t)));
  if (!buf) {
    Serial1.printf("[dither] WARN: error-diffusion buffer %lu kB alloc FAILED -> "
                   "falling back to DITHER_NONE (image will look the same as no dither).\n",
                   (unsigned long)(n * sizeof(int16_t) / 1024));
    gray4_none(rgb, W, H, gamma, out);
    return false;
  }
  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int i = (y * W + x) * 3;
      buf[y * W + x] = static_cast<int16_t>(
          apply_gamma(luma(rgb[i], rgb[i + 1], rgb[i + 2]), gamma));
    }
  }
  size_t kn = 0;
  const KernelTap* K = pick_kernel(method, kn);
  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int idx = y * W + x;
      const int old = clamp_u8(buf[idx]);
      const int q = nearest_gray4(old);
      out[idx] = static_cast<uint8_t>(q);
      const int qv = q * 85;
      const int err = old - qv;
      for (size_t k = 0; k < kn; ++k) {
        const int nx = x + K[k].dx;
        const int ny = y + K[k].dy;
        if (nx < 0 || nx >= W || ny < 0 || ny >= H) continue;
        const int ni = ny * W + nx;
        const int v = buf[ni] + err * K[k].num / K[k].den;
        buf[ni] = static_cast<int16_t>(clamp_u8(v));
      }
    }
  }
  free(buf);
  return true;
}

// ----- content classifier -----------------------------------------------------------
// Text, UI screenshots and line art are the worst case for a 6-colour panel: thin
// strokes average to light grey, and any dither turns them into speckle. Plain
// nearest-colour mapping keeps them crisp. A photo, by contrast, has thousands of
// distinct colours and plenty of chroma, so it is easy to tell the two apart.
//
// Thresholds were measured on real material (1024x921 UI screenshot: extreme 0.96,
// chroma 0.02, unique 538; scanned document: 0.80 / 0.04 / 386; photograph:
// 0.60 / 0.19 / 1273).
static inline int luma8(int r, int g, int b) { return (r * 299 + g * 587 + b * 114) / 1000; }

static bool looks_like_text_ui(const uint8_t* rgb, int W, int H, DitherMethod method) {
  const size_t n = static_cast<size_t>(W) * static_cast<size_t>(H);
  if (n < 8192) return false;   // too small to judge

  // 4-bit-per-channel colour census (4096 bins) as a bitmap.
  static uint8_t seen[4096 / 8];
  memset(seen, 0, sizeof(seen));

  size_t extreme = 0, colorful = 0, edges = 0;
  for (int y = 0; y < H; ++y) {
    const uint8_t* row = rgb + static_cast<size_t>(y) * W * 3;
    const uint8_t* next = (y + 1 < H) ? row + static_cast<size_t>(W) * 3 : nullptr;
    for (int x = 0; x < W; ++x) {
      const int i = x * 3;
      const int r = row[i], g = row[i + 1], b = row[i + 2];
      const int l = luma8(r, g, b);

      if (l < 48 || l > 208) ++extreme;
      const int mx = (r > g) ? (r > b ? r : b) : (g > b ? g : b);
      const int mn = (r < g) ? (r < b ? r : b) : (g < b ? g : b);
      if (mx - mn > 40) ++colorful;

      const int bin = ((r >> 4) << 8) | ((g >> 4) << 4) | (b >> 4);
      seen[bin >> 3] |= static_cast<uint8_t>(1u << (bin & 7));

      if (x + 1 < W) {
        const int i2 = i + 3;
        if (abs(l - luma8(row[i2], row[i2 + 1], row[i2 + 2])) > 40) ++edges;
      }
      if (next) {
        if (abs(l - luma8(next[i], next[i + 1], next[i + 2])) > 40) ++edges;
      }
    }
  }

  size_t uniq = 0;
  for (size_t i = 0; i < sizeof(seen); ++i) uniq += (size_t)__builtin_popcount(seen[i]);

  const double ex = (double)extreme / (double)n;
  const double co = (double)colorful / (double)n;
  const double ed = (double)edges / (double)n;

  const bool text = (ex >= 0.70) && (co <= 0.08) && (uniq <= 700) && (ed >= 0.01);

  Serial1.printf("[dither] content: extreme=%.2f color=%.2f edges=%.2f uniq=%u -> %s\n",
                 ex, co, ed, (unsigned)uniq,
                 text ? "text/UI (no dither)" : "photo (dither)");
  if (text && method != DITHER_NONE) {
    Serial1.println("[dither]   thin strokes would speckle -- using nearest colour");
  }
  return text;
}

// ----- E6 ---------------------------------------------------------------------------

static void e6_none(const uint8_t* rgb, int W, int H, uint8_t* out) {
  for (int i = 0, p = 0; p < W * H; ++p, i += 3) {
    const int q = nearest_e6(rgb[i], rgb[i + 1], rgb[i + 2]);
    out[p] = kE6Code[q];
  }
}

static void e6_bayer(const uint8_t* rgb, int W, int H, uint8_t* out) {
  const int spread = 64;
  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int i = (y * W + x) * 3;
      // mod ∈ [-spread/2, +spread/2]
      const int mod = ((kBayer8[(y & 7) * 8 + (x & 7)] * spread) >> 6) - (spread >> 1);
      const int r = clamp_u8(rgb[i + 0] + mod);
      const int g = clamp_u8(rgb[i + 1] + mod);
      const int b = clamp_u8(rgb[i + 2] + mod);
      out[y * W + x] = kE6Code[nearest_e6(r, g, b)];
    }
  }
}

// Same idea as e6_bayer, but the threshold comes from a blue-noise matrix:
// same dot density, no periodic cross-hatch, so gradients read as fine grain.
static void e6_blue(const uint8_t* rgb, int W, int H, uint8_t* out) {
  const int spread = 64;
  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int i = (y * W + x) * 3;
      const int t = kBlueNoise32[(y & 31) * 32 + (x & 31)];
      const int mod = ((t * spread) >> 8) - (spread >> 1);
      const int r = clamp_u8(rgb[i + 0] + mod);
      const int g = clamp_u8(rgb[i + 1] + mod);
      const int b = clamp_u8(rgb[i + 2] + mod);
      out[y * W + x] = kE6Code[nearest_e6(r, g, b)];
    }
  }
}

// Yliluoma-style arbitrary-palette ordered dithering, three inks per pixel.
//
// For every pixel: pick the three palette entries closest to the target colour,
// find the point of that triangle closest to the target (barycentric, clamped to
// the edges), then let the blue-noise threshold decide which of the three to
// place. Over a 32x32 tile the mixing ratio reproduces the target much better
// than nudging RGB and taking the nearest ink, and three inks reach colours that
// no pair of inks can (two inks only cover the segments between palette points,
// three cover the triangles).
namespace {

inline float e6_dist2(const float* p, const float* q) {
  const float x = p[0] - q[0], y = p[1] - q[1], z = p[2] - q[2];
  return 2.0f * x * x + 4.0f * y * y + 3.0f * z * z;   // green carries luminance
}

// Closest point of triangle ABC to P, expressed as barycentric weights.
void closest_in_triangle(const float A[3], const float B[3], const float C[3],
                         const float P[3], float& wa, float& wb, float& wc) {
  float v0[3] = {B[0] - A[0], B[1] - A[1], B[2] - A[2]};
  float v1[3] = {C[0] - A[0], C[1] - A[1], C[2] - A[2]};
  float v2[3] = {P[0] - A[0], P[1] - A[1], P[2] - A[2]};

  const float d00 = v0[0]*v0[0] + v0[1]*v0[1] + v0[2]*v0[2];
  const float d01 = v0[0]*v1[0] + v0[1]*v1[1] + v0[2]*v1[2];
  const float d11 = v1[0]*v1[0] + v1[1]*v1[1] + v1[2]*v1[2];
  const float d20 = v2[0]*v0[0] + v2[1]*v0[1] + v2[2]*v0[2];
  const float d21 = v2[0]*v1[0] + v2[1]*v1[1] + v2[2]*v1[2];
  const float denom = d00 * d11 - d01 * d01;

  if (fabsf(denom) > 1.0f) {
    const float v = (d11 * d20 - d01 * d21) / denom;
    const float w = (d00 * d21 - d01 * d20) / denom;
    const float u = 1.0f - v - w;
    if (u >= 0.0f && v >= 0.0f && w >= 0.0f) {
      wa = u; wb = v; wc = w;
      return;
    }
  }

  // Outside the triangle: closest point lies on one of the edges.
  float best = 1e30f;
  const float* pts[3] = {A, B, C};

  for (int e = 0; e < 3; ++e) {
    const float* X = pts[e];
    const float* Y = pts[(e + 1) % 3];
    float d[3] = {Y[0] - X[0], Y[1] - X[1], Y[2] - X[2]};
    const float len2 = d[0]*d[0] + d[1]*d[1] + d[2]*d[2];
    float t = 0.0f;
    if (len2 > 0.0f) {
      t = ((P[0]-X[0])*d[0] + (P[1]-X[1])*d[1] + (P[2]-X[2])*d[2]) / len2;
      if (t < 0.0f) t = 0.0f;
      else if (t > 1.0f) t = 1.0f;
    }
    float m[3] = {X[0] + d[0]*t, X[1] + d[1]*t, X[2] + d[2]*t};
    const float dd = e6_dist2(m, P);
    if (dd < best) {
      best = dd;
      float w[3] = {0, 0, 0};
      w[e] = 1.0f - t;
      w[(e + 1) % 3] = t;
      wa = w[0]; wb = w[1]; wc = w[2];
    }
  }
}

}  // namespace

// Best-fitting ink triple per 5-bit RGB cell, built once at first use.
// Searching all 20 triples per pixel would cost too much, and picking "the three
// nearest inks" gets neutrals wrong (grey comes out red+green+blue). A 32^3
// table of the best triple costs ~98 KB and turns that search into a lookup;
// the exact mixing ratios are still computed per pixel, so gradients don't band.
struct YloTriple { uint8_t a, b, c; };

static const uint8_t kYloCombos[20][3] = {
    {0,1,2},{0,1,3},{0,1,4},{0,1,5},{0,2,3},{0,2,4},{0,2,5},{0,3,4},{0,3,5},{0,4,5},
    {1,2,3},{1,2,4},{1,2,5},{1,3,4},{1,3,5},{1,4,5},
    {2,3,4},{2,3,5},{2,4,5},{3,4,5},
};

static const float kE6Pal[6][3] = {
    {255.0f, 255.0f, 255.0f},
    { 29.0f, 185.0f,  84.0f},
    {229.0f,  57.0f,  53.0f},
    {255.0f, 216.0f,   0.0f},
    {  0.0f,  76.0f, 255.0f},
    {  0.0f,   0.0f,   0.0f},
};

YloTriple* g_ylo_lut = nullptr;
bool       g_ylo_tried = false;

bool ensure_ylo_lut() {
  if (g_ylo_lut) return true;
  if (g_ylo_tried) return false;
  g_ylo_tried = true;

  const size_t cells = 32 * 32 * 32;
  g_ylo_lut = static_cast<YloTriple*>(ps_malloc(cells * sizeof(YloTriple)));
  if (!g_ylo_lut) g_ylo_lut = static_cast<YloTriple*>(malloc(cells * sizeof(YloTriple)));
  if (!g_ylo_lut) {
    Serial1.println("[dither] WARN: YLO LUT alloc FAILED -> nearest colour");
    return false;
  }

  size_t n = 0;
  for (int ri = 0; ri < 32; ++ri) {
    for (int gi = 0; gi < 32; ++gi) {
      for (int bi = 0; bi < 32; ++bi) {
        const float P[3] = {ri * 255.0f / 31.0f, gi * 255.0f / 31.0f, bi * 255.0f / 31.0f};
        float bestD = 1e30f;
        uint8_t ba = 0, bb = 1, bc = 2;
        for (int k = 0; k < 20; ++k) {
          const uint8_t* c = kYloCombos[k];
          float w[3];
          closest_in_triangle(kE6Pal[c[0]], kE6Pal[c[1]], kE6Pal[c[2]], P, w[0], w[1], w[2]);
          float m[3];
          for (int j = 0; j < 3; ++j)
            m[j] = w[0] * kE6Pal[c[0]][j] + w[1] * kE6Pal[c[1]][j] + w[2] * kE6Pal[c[2]][j];
          const float d = e6_dist2(m, P);
          if (d < bestD) { bestD = d; ba = c[0]; bb = c[1]; bc = c[2]; }
        }
        g_ylo_lut[n].a = ba;
        g_ylo_lut[n].b = bb;
        g_ylo_lut[n].c = bc;
        ++n;
      }
    }
  }
  Serial1.println("[dither] YLO LUT built (20 triples per cell)");
  return true;
}

static void e6_yliluoma(const uint8_t* rgb, int W, int H, uint8_t* out) {
  if (!ensure_ylo_lut()) {
    e6_none(rgb, W, H, out);
    return;
  }

  for (int y = 0; y < H; ++y) {
    for (int x = 0; x < W; ++x) {
      const int i = (y * W + x) * 3;
      const int r = rgb[i + 0], g = rgb[i + 1], b = rgb[i + 2];

      const int bin = ((r >> 3) << 10) | ((g >> 3) << 5) | (b >> 3);
      const YloTriple t = g_ylo_lut[bin];

      const float P[3] = {(float)r, (float)g, (float)b};
      float w[3];
      closest_in_triangle(kE6Pal[t.a], kE6Pal[t.b], kE6Pal[t.c], P, w[0], w[1], w[2]);

      int idx[3] = {t.a, t.b, t.c};
      for (int a = 0; a < 2; ++a) {
        for (int bb2 = a + 1; bb2 < 3; ++bb2) {
          if (w[bb2] > w[a]) {
            const float s = w[a]; w[a] = w[bb2]; w[bb2] = s;
            const int si = idx[a]; idx[a] = idx[bb2]; idx[bb2] = si;
          }
        }
      }

      int t1 = (int)(w[0] * 256.0f + 0.5f);
      int t2 = (int)((w[0] + w[1]) * 256.0f + 0.5f);
      if (t1 < 0) t1 = 0; else if (t1 > 256) t1 = 256;
      if (t2 < t1) t2 = t1; else if (t2 > 256) t2 = 256;

      const int th = kBlueNoise32[(y & 31) * 32 + (x & 31)];
      const int q = (th < t1) ? idx[0] : (th < t2 ? idx[1] : idx[2]);
      out[y * W + x] = kE6Code[q];
    }
  }
}

static bool e6_diffuse(const uint8_t* rgb, int W, int H,
                       DitherMethod method, uint8_t* out) {
  size_t kn = 0;
  const KernelTap* K = pick_kernel(method, kn);

  // Only the rows a kernel can still reach need to exist: Floyd-Steinberg looks
  // one row ahead, Jarvis two. A ring of (maxdy + 1) rows costs ~13-20 KB
  // instead of 3 * int16 per pixel (5.3 MB for 1100x824), which is what used to
  // make error diffusion impossible on this panel.
  int maxdy = 0;
  for (size_t k = 0; k < kn; ++k)
    if (K[k].dy > maxdy) maxdy = K[k].dy;
  const int rows = maxdy + 1;

  const size_t row_vals = static_cast<size_t>(W) * 3;
  const size_t total = row_vals * static_cast<size_t>(rows);
  int16_t* err = static_cast<int16_t*>(ps_malloc(total * sizeof(int16_t)));
  if (!err) err = static_cast<int16_t*>(malloc(total * sizeof(int16_t)));
  if (!err) {
    Serial1.printf("[dither] WARN: E6 error rows %lu kB alloc FAILED -> "
                   "falling back to nearest colour\n",
                   (unsigned long)(total * sizeof(int16_t) / 1024));
    e6_none(rgb, W, H, out);
    return false;
  }
  memset(err, 0, total * sizeof(int16_t));

  for (int y = 0; y < H; ++y) {
    int16_t* cur = err + static_cast<size_t>(y % rows) * row_vals;
    const uint8_t* src = rgb + static_cast<size_t>(y) * W * 3;

    for (int x = 0; x < W; ++x) {
      const int o = x * 3;
      const int r = clamp_u8(src[o + 0] + cur[o + 0]);
      const int g = clamp_u8(src[o + 1] + cur[o + 1]);
      const int b = clamp_u8(src[o + 2] + cur[o + 2]);
      const int q = nearest_e6(r, g, b);
      out[static_cast<size_t>(y) * W + x] = kE6Code[q];

      const int err_r = r - kE6Rgb[q].r;
      const int err_g = g - kE6Rgb[q].g;
      const int err_b = b - kE6Rgb[q].b;

      for (size_t k = 0; k < kn; ++k) {
        const int nx = x + K[k].dx;
        const int ny = y + K[k].dy;
        if (nx < 0 || nx >= W || ny >= H) continue;
        int16_t* dst = err + static_cast<size_t>(ny % rows) * row_vals + nx * 3;
        dst[0] = static_cast<int16_t>(clamp_u8(dst[0] + err_r * K[k].num / K[k].den));
        dst[1] = static_cast<int16_t>(clamp_u8(dst[1] + err_g * K[k].num / K[k].den));
        dst[2] = static_cast<int16_t>(clamp_u8(dst[2] + err_b * K[k].num / K[k].den));
      }
    }

    // This slot is reused for row y + rows; every kernel that can reach that row
    // (at most y+1) runs after this point, so clearing now is safe.
    memset(cur, 0, row_vals * sizeof(int16_t));
  }

  free(err);
  return true;
}

}  // namespace

bool dither_image(const uint8_t* rgb888, int width, int height,
                  DitherPalette palette, DitherMethod method,
                  float gamma, bool invert,
                  uint8_t* out_index, bool auto_text_mode) {
  if (!rgb888 || !out_index || width <= 0 || height <= 0) return false;

  switch (palette) {
    case PAL_BW: {
      if (method == DITHER_NONE)        bw_none (rgb888, width, height, gamma, out_index);
      else if (method == DITHER_BAYER8 || method == DITHER_BN) bw_bayer(rgb888, width, height, gamma, out_index);
      else                              bw_diffuse(rgb888, width, height, gamma, method, out_index);
      if (invert) {
        for (size_t p = 0, n = static_cast<size_t>(width) * height; p < n; ++p)
          out_index[p] ^= 1;
      }
      return true;
    }
    case PAL_GRAY4: {
      if (method == DITHER_NONE)        gray4_none (rgb888, width, height, gamma, out_index);
      else if (method == DITHER_BAYER8 || method == DITHER_BN) gray4_bayer(rgb888, width, height, gamma, out_index);
      else                              gray4_diffuse(rgb888, width, height, gamma, method, out_index);
      return true;
    }
    case PAL_GRAY16: {
      if (method == DITHER_NONE)        gray16_none (rgb888, width, height, gamma, out_index);
      else if (method == DITHER_BAYER8 || method == DITHER_BN) gray16_bayer(rgb888, width, height, gamma, out_index);
      else                              gray16_diffuse(rgb888, width, height, gamma, method, out_index);
      return true;
    }
    case PAL_E6: {
      // Text/UI content is rendered without dithering, whatever the caller asked
      // for -- see looks_like_text_ui().
      const bool no_dither =
          auto_text_mode && looks_like_text_ui(rgb888, width, height, method);

      // Gamma is supported for E6 by pre-adjusting each channel with the same curve.
      if (gamma < 0.999f || gamma > 1.001f) {
        const size_t n = static_cast<size_t>(width) * height;
        uint8_t* tmp = static_cast<uint8_t*>(ps_malloc(n * 3));
        if (!tmp) tmp = static_cast<uint8_t*>(malloc(n * 3));
        if (tmp) {
          for (size_t i = 0; i < n * 3; ++i) tmp[i] = apply_gamma(rgb888[i], gamma);
          rgb888 = tmp;
          if (no_dither)                    e6_none (rgb888, width, height, out_index);
          else if (method == DITHER_NONE)   e6_none (rgb888, width, height, out_index);
          else if (method == DITHER_BAYER8) e6_bayer(rgb888, width, height, out_index);
          else if (method == DITHER_BN)     e6_blue (rgb888, width, height, out_index);
          else if (method == DITHER_YLO)    e6_yliluoma(rgb888, width, height, out_index);
          else                              e6_diffuse(rgb888, width, height, method, out_index);
          free(tmp);
          return true;
        }
        // alloc failed -> fall through with original buffer
      }
      if (no_dither)                    e6_none (rgb888, width, height, out_index);
      else if (method == DITHER_NONE)   e6_none (rgb888, width, height, out_index);
      else if (method == DITHER_BAYER8) e6_bayer(rgb888, width, height, out_index);
      else if (method == DITHER_BN)     e6_blue (rgb888, width, height, out_index);
      else if (method == DITHER_YLO)    e6_yliluoma(rgb888, width, height, out_index);
      else                              e6_diffuse(rgb888, width, height, method, out_index);
      return true;
    }
  }
  return false;
}

void pack_1bpp_msb(const uint8_t* bw_index, uint8_t* out_bits,
                   int width, int height, bool bit_for_black) {
  const int row_bytes = (width + 7) / 8;
  for (int y = 0; y < height; ++y) {
    const uint8_t* row = bw_index + y * width;
    uint8_t* dst = out_bits + y * row_bytes;
    for (int x = 0; x < width; x += 8) {
      uint8_t byte = 0;
      for (int b = 0; b < 8; ++b) {
        const int xi = x + b;
        const bool is_black = (xi < width) ? (row[xi] == 0) : false;
        const int bit = bit_for_black ? (is_black ? 1 : 0) : (is_black ? 0 : 1);
        byte |= static_cast<uint8_t>((bit & 1) << (7 - b));
      }
      dst[x / 8] = byte;
    }
  }
}
